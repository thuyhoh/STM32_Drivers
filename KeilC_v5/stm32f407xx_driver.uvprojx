# Keil uVision project stm32f407xx_driver.uvprojx, settings and files
target Application (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407xx_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\CortexMx\Drivers\Inc;..\..\..\Drivers\STM32\STM32F407VG_Drivers\Inc;..\..\..\Drivers\STM32\STM32F407VG_Drivers\Src;..\..\..\Drivers\ARM\m4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./: main.h
  group Src
    ./: main.c
  group m4
    ../../../Drivers/ARM/m4/: CortexM4.c CortexM4.h
  group Lib_inc
    ../../../Drivers/STM32/STM32F407VG_Drivers/Inc/: stm32f407xx.h stm32f407xx_adc_driver.h stm32f407xx_bxcan_driver.h stm32f407xx_dma_driver.h stm32f407xx_exti_driver.h stm32f407xx_flash_driver.h stm32f407xx_gpio_driver.h stm32f407xx_i2c_driver.h stm32f407xx_iwdg_driver.h stm32f407xx_pwr_driver.h stm32f407xx_rcc_driver.h stm32f407xx_rtc_driver.h stm32f407xx_spi_driver.h stm32f407xx_timer_driver.h stm32f407xx_uart_driver.h stm32f407xx_wwdg_driver.h
  group Lib_src
    ../../../Drivers/STM32/STM32F407VG_Drivers/Src/: stm32f407xx_adc_driver.c stm32f407xx_bxcan_driver.c stm32f407xx_dma_driver.c stm32f407xx_exti_driver.c stm32f407xx_flash_driver.c stm32f407xx_gpio_driver.c stm32f407xx_i2c_driver.c stm32f407xx_iwdg_driver.c stm32f407xx_pwr_driver.c stm32f407xx_rcc_driver.c stm32f407xx_rtc_driver.c stm32f407xx_spi_driver.c stm32f407xx_timer_driver.c stm32f407xx_uart_driver.c stm32f407xx_wwdg_driver.c
  group example
    ./Example/: 001_HSE_HSI_Configure.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
